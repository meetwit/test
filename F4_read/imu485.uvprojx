# Keil uVision project imu485.uvprojx, settings and files
target imu485 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: imu485
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\INC;.\USMART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ./SRC/: main.c thread_mw.c
  group DEVICE
    ./SRC/: sys.c ANO.c hx711.c JY901.c rs485.c delay.c usart45.c xnumx.c
  group USAMART
    ./USMART/: usart.c
  group README
    ./: readme.txt
software components: CMSIS:CORE 5.1.2, Device:Startup 2.5.0
